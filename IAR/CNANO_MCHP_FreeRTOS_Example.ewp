# IAR project CNANO_MCHP_FreeRTOS_Example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: CNANO_MCHP_FreeRTOS_Example.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: app.c main.c main.h retarget.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/MCHP-PLIB NVMCTRL
    ${CMSIS_PACK_PATH_Microchip#CMSIS-Driver_PIC32CM-JH#0.52.0-dev.10}$/PIC32CM64_32-JH00/plib/Source/: plib_nvmctrl.c
  group CMSIS-Pack/ARM FreeRTOS _RTOS.Config.CMSIS RTOS2_11.2.0
    ../RTE/RTOS/: FreeRTOSConfig.h
  group CMSIS-Pack/ARM FreeRTOS _RTOS.Core.Cortex-M_11.2.0
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#11.2.0}$/CMSIS/RTOS2/FreeRTOS/Source/: freertos_evr.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#11.2.0}$/Source/: list.c queue.c tasks.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#11.2.0}$/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group CMSIS-Pack/ARM FreeRTOS _RTOS.Event Groups_11.2.0
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#11.2.0}$/Source/: event_groups.c
  group CMSIS-Pack/ARM FreeRTOS _RTOS.Heap.Heap_4_11.2.0
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#11.2.0}$/Source/portable/MemMang/: heap_4.c
  group CMSIS-Pack/ARM FreeRTOS _RTOS.Timers_11.2.0
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#11.2.0}$/Source/: timers.c
  group CMSIS-Pack/CMSIS Driver GPIO
    ${CMSIS_PACK_PATH_Microchip#CMSIS-Driver_PIC32CM-JH#0.52.0-dev.10}$/PIC32CM64_32-JH00/driver/cmsis/Source/: Driver_GPIO.c
  group CMSIS-Pack/CMSIS Driver.USART USART1
    RTE/CMSIS_Driver/PIC32CM6408JH00064/: Config_USART1.h Config_USART_Pins.h
    ${CMSIS_PACK_PATH_Microchip#CMSIS-Driver_PIC32CM-JH#0.52.0-dev.10}$/PIC32CM64_32-JH00/driver/cmsis/Source/: Driver_USART1.c
  group CMSIS-Pack/CMSIS-Compiler CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS-Compiler#2.2.0}$/source/core/iar/: retarget_io.c
  group CMSIS-Pack/CMSIS.OS Tick SysTick
    ${CMSIS_PACK_PATH_ARM#CMSIS#6.3.0}$/CMSIS/RTOS2/Source/: os_systick.c
  group CMSIS-Pack/CMSIS.RTOS2.FreeRTOS Cortex-M
    ${CMSIS_PACK_PATH_ARM#CMSIS-FreeRTOS#11.2.0}$/CMSIS/RTOS2/FreeRTOS/Source/: clib_os.c cmsis_os2.c
  group CMSIS-Pack/Device Startup
    RTE/Device/PIC32CM6408JH00064/: flash.icf rww.icf sram.icf startup_pic32cm6408jh00064.c system_pic32cm6408jh00064.c
  group CMSIS-Pack/MCHP-PLIB GCLK
    ${CMSIS_PACK_PATH_Microchip#CMSIS-Driver_PIC32CM-JH#0.52.0-dev.10}$/PIC32CM64_32-JH00/plib/Source/: plib_gclk.c
  group CMSIS-Pack/MCHP-PLIB MCLK
    ${CMSIS_PACK_PATH_Microchip#CMSIS-Driver_PIC32CM-JH#0.52.0-dev.10}$/PIC32CM64_32-JH00/plib/Source/: plib_mclk.c
  group CMSIS-Pack/MCHP-PLIB OSC32KCTRL
    ${CMSIS_PACK_PATH_Microchip#CMSIS-Driver_PIC32CM-JH#0.52.0-dev.10}$/PIC32CM64_32-JH00/plib/Source/: plib_osc32kctrl.c
  group CMSIS-Pack/MCHP-PLIB OSCCTRL
    ${CMSIS_PACK_PATH_Microchip#CMSIS-Driver_PIC32CM-JH#0.52.0-dev.10}$/PIC32CM64_32-JH00/plib/Source/: plib_clock.c plib_oscctrl.c
  group CMSIS-Pack/MCHP-PLIB PORT
    ${CMSIS_PACK_PATH_Microchip#CMSIS-Driver_PIC32CM-JH#0.52.0-dev.10}$/PIC32CM64_32-JH00/plib/Source/: plib_port.c
  group CMSIS-Pack/MCHP-PLIB System Interrupt
    ${CMSIS_PACK_PATH_Microchip#CMSIS-Driver_PIC32CM-JH#0.52.0-dev.10}$/PIC32CM64_32-JH00/plib/Source/: system_interrupt.c
  group CMSIS-Pack/MCHP-PLIB.SERCOM SERCOM_USART1
    ${CMSIS_PACK_PATH_Microchip#CMSIS-Driver_PIC32CM-JH#0.52.0-dev.10}$/PIC32CM64_32-JH00/plib/Source/: plib_sercom1_interrupt.c plib_sercom1_usart.c
