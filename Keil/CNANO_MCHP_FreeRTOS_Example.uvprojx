# Keil uVision project CNANO_MCHP_FreeRTOS_Example.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: PIC32CM6408JH00064 Microchip
  pack: Microchip.PIC32CM-JH_DFP.1.6.279
  cpu: IRAM(0x20000000,0x2000) IRAM2(0x40000000,0x4000) IROM(0x00000000,0x10000) IROM2(0x00400000,0x800) XRAM(0x41000000,0x10000) XRAM2(0x42000000,0x8000) XRAM3(0x48000000,0x20) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CNANO_MCHP_FreeRTOS_Example
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x400000 size 0x800
  memory RVCT6: RAM 0x41000000 size 0x10000
  memory RVCT7: RAM 0x42000000 size 0x8000
  memory RVCT8: RAM 0x48000000 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x40000000 size 0x4000
  scatter file: .\RTE\Device\PIC32CM6408JH00064\pic32cm6408jh00064_flash.sct
  group Source Group 1
    ../: app.c main.c retarget.c main.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0, CMSIS Driver:GPIO 1.0.0, CMSIS Driver:USART:USART1 1.1.0, Device:Startup 1.6.0, MCHP-PLIB:GCLK 2.0.0, MCHP-PLIB:MCLK 2.0.0, MCHP-PLIB:NVMCTRL 1.0.0-rc.1, MCHP-PLIB:OSC32KCTRL 1.0.0-rc.1, MCHP-PLIB:OSCCTRL 1.0.0-rc.3, MCHP-PLIB:PORT 1.0.0, MCHP-PLIB:SERCOM:SERCOM_USART1 1.0.1, MCHP-PLIB:System Interrupt 1.0.0
